# Keil uVision project RTOS-RobotPrep.uvproj, settings and files
target RTOS_Lab_3 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: RTOS-lab1
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --C99
  c include: .\;.\CMSIS;.\Inc;.\Src;.\Objects;.\Listings
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Src
    ./Src/: main.c ADC.c Interpreter.c OS.c PLL.c ST7735.c Timer2.c UART.c OSasm.s can.c can0.c interrupt.c
  group Inc
    ./Inc/: tm4c123gh6pm.h UART.h ST7735.h retarget.h PLL.h OS.h Interpreter.h FIFO.h ADCSWTrigger.h ADC.h can.h can0.h debug.h hw_can.h hw_ints.h hw_memmap.h hw_nvic.h hw_types.h interrupt.h
  group CMSIS
    ./CMSIS/: startup.s
