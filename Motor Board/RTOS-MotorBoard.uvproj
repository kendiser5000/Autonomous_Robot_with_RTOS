# Keil uVision project RTOS-MotorBoard.uvproj, settings and files
target RTOS_MotorBoard (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: RTOS-MotorBoard
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --C99
  c include: \;.\CMSIS;.\Inc;.\Src;.\Objects;.\Listings;.\Src\VL53L0X;.\Src\VL53L0X\VL53L0X_I2C;.\Src\VL53L0X\platform\src;.\Src\VL53L0X\platform\inc;.\Src\VL53L0X\core\src;.\Src\VL53L0X\core\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Src
    ./Src/: main.c Interpreter.c OS.c PLL.c UART.c OSasm.s can.c can0.c interrupt.c MotorControl.c ToF.c PWM.c
    ./Src/VL53L0X/: VL53L0X.c
    ./Src/VL53L0X/VL53L0X_I2C/: VL53L0X_I2C.c
    ./Src/VL53L0X/platform/src/: vl53l0x_platform.c
    ./Src/VL53L0X/core/src/: vl53l0x_api.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_calibration.c vl53l0x_api_strings.c
  group Inc
    ./Inc/: tm4c123gh6pm.h UART.h PLL.h OS.h Interpreter.h FIFO.h can.h can0.h debug.h hw_can.h hw_ints.h hw_memmap.h hw_nvic.h hw_types.h interrupt.h MotorControl.h ToF.h PWM.h Filter.h
    ./Src/VL53L0X/: VL53L0X.h
    ./Src/VL53L0X/VL53L0X_I2C/: VL53L0X_I2C.h
    ./Src/VL53L0X/platform/inc/: vl53l0x_platform.h vl53l0x_platform_log.h vl53l0x_types.h
    ./Src/VL53L0X/core/inc/: vl53l0x_api.h vl53l0x_api_calibration.h vl53l0x_api_core.h vl53l0x_api_ranging.h vl53l0x_api_strings.h vl53l0x_def.h vl53l0x_device.h vl53l0x_i2c_platform.h vl53l0x_interrupt_threshold_settings.h vl53l0x_tuning.h
  group CMSIS
    ./CMSIS/: startup.s
